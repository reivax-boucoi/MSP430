<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP-5510STK_Blinking_LED\MSP-5510STK_Blinking_LED.ewp</path>
  </project>
  <batchBuild/>
</workspace>


