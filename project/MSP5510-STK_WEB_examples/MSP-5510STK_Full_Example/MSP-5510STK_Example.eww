<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\IAR\5510\MSP-5510STK_Blinking_Led\MSP-5510STK_Blinking_Led.ewp</path>
    </project>
    <batchBuild />
</workspace>
