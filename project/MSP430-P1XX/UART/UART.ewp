# IAR project UART.ewp, settings and files
configuration MSP430-P1XX (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MSP430_1XX
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration MSP430-P2XX (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F249 MSP430F249
  ICC430.CCDefines: MSP430_2XX
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F249.xcl
  group (top)
    ./: main.c uart0.c usart.c
